# Keil uVision project hello.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c hw_i2c.c hw_ssd1306.c hw_mcu.c hw_mcu.h sys_time.c sys_time.h hw_ssd1306.h fontArial16.c gontArial24.c hw_dma.c hw_dma.h ws2812.c ws2812.h
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.0
